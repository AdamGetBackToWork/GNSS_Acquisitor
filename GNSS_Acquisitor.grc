options:
  parameters:
    generate_options: qt_gui
    id: GNSS_Acquisitor
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: code_step
  id: variable
  parameters:
    value: '1'
  states: {}
- name: dopp_max
  id: variable
  parameters:
    value: '5000.0'
  states: {}
- name: dopp_step
  id: variable
  parameters:
    value: '500.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /Users/adam/Studia/MGR/SEM2/TRPZ/PRO/Test/L1_10s_skipped10000.iq
    repeat: 'True'
    type: short
  states: {}
- name: blocks_interleaved_short_to_complex_1
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import scipy.fft as _fft

      #  Constants
      CA_RATE = 1.023e6
      CA_LEN = 1023

      # G2 phase selector taps (1-based stages) for PRN 1..32
      G2_TAPS = {
          1: (2, 6), 2: (3, 7), 3: (4, 8), 4: (5, 9), 5: (1, 9), 6: (2, 10),
          7: (1, 8), 8: (2, 9), 9: (3, 10), 10: (2, 3), 11: (3, 4), 12: (5, 6),
          13: (6, 7), 14: (7, 8), 15: (8, 9), 16: (9, 10), 17: (1, 4), 18: (2, 5),
          19: (3, 6), 20: (4, 7), 21: (5, 8), 22: (6, 9), 23: (1, 3), 24: (4, 6),
          25: (5, 7), 26: (6, 8), 27: (7, 9), 28: (8, 10), 29: (1, 6), 30: (2, 7),
          31: (3, 8), 32: (4, 9),
      }

      # Initial parameter values - to be overwritten by grc simulation parameters
      SAMPLING_FREQ = 25e6
      DOPPLER_STEP  = 500.0
      DOPPLER_MAX   = 5000.0
      CODE_STEP     = 1
      SKIP_MS       = 0




      # --------------------------------------------------------------------------
      # Acquisition DSP
      # --------------------------------------------------------------------------

      # # Generate CA Codes of GPS
      # def ca_code():

      # # Resample the CA code to the specific f_s
      # def resample_code():

      # # 
      # def acquire_prn():  

      # # 
      # def acquire_iq_samples():


      class blk(gr.sync_block):
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sampling_freq = SAMPLING_FREQ, doppler_step = DOPPLER_STEP, 
                      doppler_max = DOPPLER_MAX, code_step = CODE_STEP, skip_ms = SKIP_MS, 
                      ): 
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='GPS Acquisitor',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.sampling_freq = sampling_freq
              self.doppler_step  = doppler_step
              self.doppler_max   = doppler_max
              self.code_step     = code_step
              self.skip_ms       = skip_ms


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    code_step: code_step
    doppler_max: dopp_max
    doppler_step: dopp_step
    sampling_freq: samp_rate
    skip_ms: '0'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import scipy.fft as _fft

      #  Constants
      CA_RATE = 1.023e6
      CA_LEN = 1023

      # G2 phase selector taps (1-based stages) for PRN 1..32
      G2_TAPS = {
          1: (2, 6), 2: (3, 7), 3: (4, 8), 4: (5, 9), 5: (1, 9), 6: (2, 10),
          7: (1, 8), 8: (2, 9), 9: (3, 10), 10: (2, 3), 11: (3, 4), 12: (5, 6),
          13: (6, 7), 14: (7, 8), 15: (8, 9), 16: (9, 10), 17: (1, 4), 18: (2, 5),
          19: (3, 6), 20: (4, 7), 21: (5, 8), 22: (6, 9), 23: (1, 3), 24: (4, 6),
          25: (5, 7), 26: (6, 8), 27: (7, 9), 28: (8, 10), 29: (1, 6), 30: (2, 7),
          31: (3, 8), 32: (4, 9),
      }

      # Initial parameter values - to be overwritten by grc simulation parameters
      SAMPLING_FREQ = 25e6
      DOPPLER_STEP  = 500.0
      DOPPLER_MAX   = 5000.0
      CODE_STEP     = 1
      SKIP_MS       = 0




      # --------------------------------------------------------------------------
      # Acquisition DSP
      # --------------------------------------------------------------------------

      # # Generate CA Codes of GPS
      # def ca_code():

      # # Resample the CA code to the specific f_s
      # def resample_code():

      # # 
      # def acquire_prn():  

      # # 
      # def acquire_iq_samples():


      class blk(gr.sync_block):
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, sampling_freq = SAMPLING_FREQ, doppler_step = DOPPLER_STEP, 
                      doppler_max = DOPPLER_MAX, code_step = CODE_STEP, skip_ms = SKIP_MS, 
                      ): 
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Galileo Acquisitor',
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.sampling_freq = sampling_freq
              self.doppler_step  = doppler_step
              self.doppler_max   = doppler_max
              self.code_step     = code_step
              self.skip_ms       = skip_ms


          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    code_step: code_step
    doppler_max: dopp_max
    doppler_step: dopp_step
    sampling_freq: samp_rate
    skip_ms: '0'
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_interleaved_short_to_complex_1, '0']
- [blocks_interleaved_short_to_complex_1, '0', epy_block_1, '0']
- [blocks_interleaved_short_to_complex_1, '0', epy_block_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
